Commit message: Merged from kavrakilab branch.

File: ur_description/urdf/2_ur5.urdf (robot description, URDF)
Before this commit: robot ur5_robotiq85_kinect, 40 links, 39 joints
Links:
- link box_link: geometry collision box size=2.286 1.524 0.9144; visual box size=2.286 1.524 0.9144
